options:
  parameters:
    generate_options: qt_gui
    id: tx_rx_sim
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: payload
  id: variable
  parameters:
    value: '"Hej"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 250e3
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("trig")
    period: '500'
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '1'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: digital_gfsk_demod_0
  id: digital_gfsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: '2'
    sensitivity: '1.0'
  states: {}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.35'
    do_unpack: 'False'
    samples_per_symbol: '2'
    sensitivity: '1.0'
  states: {}
- name: nordic_nordic_rx_0
  id: nordic_nordic_rx
  parameters:
    SB_payload_length: len(payload)
    address_length: '5'
    address_match: ''
    channel: '120'
    crc_length: '2'
    data_rate: '2'
    protocol: '0'
  states: {}
- name: nordic_nordic_tx_0
  id: nordic_nordic_tx
  parameters:
    channel_count: '1'
    protocol: '0'
  states: {}
- name: nordic_nordictap_printer_0
  id: nordic_nordictap_printer
  parameters: {}
  states: {}
- name: nordic_nordictap_transmitter_0
  id: nordic_nordictap_transmitter
  parameters:
    ack: '0'
    address: '''\xE7\xE7\xE7\xE7\xE7'''
    big_packet: '0'
    channel_count: '120'
    channel_index: '0'
    crc_length: '2'
    data_rate: '2'
    payload: payload
    sequence_number: '0'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"tx_sob"'
    type: complex
  states: {}

connections:
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_message_strobe_0, strobe, nordic_nordictap_transmitter_0, trig]
- [blocks_repack_bits_bb_0, '0', digital_gfsk_mod_0, '0']
- [blocks_throttle_0, '0', nordic_nordic_rx_0, '0']
- [digital_gfsk_demod_0, '0', blocks_char_to_float_0, '0']
- [digital_gfsk_demod_0, '0', blocks_throttle_0, '0']
- [digital_gfsk_mod_0, '0', digital_gfsk_demod_0, '0']
- [digital_gfsk_mod_0, '0', qtgui_time_sink_x_1, '0']
- [nordic_nordic_rx_0, nordictap_out, nordic_nordictap_printer_0, nordictap_in]
- [nordic_nordic_tx_0, '0', blocks_repack_bits_bb_0, '0']
- [nordic_nordictap_transmitter_0, nordictap_out, nordic_nordic_tx_0, nordictap_in]

metadata:
  file_format: 1
