options:
  parameters:
    generate_options: qt_gui
    id: nrf24_usrp_tx
    output_language: python
    title: usrp_nrf24_tx
  states: {}

blocks:
- name: payload
  id: variable
  parameters:
    value: '"Transmitting"'
  states: {}
- name: payload_length
  id: variable
  parameters:
    value: len(payload)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 4e6
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("trig")
    period: '1000'
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '1'
  states: {}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: '500e-3'
    samples_per_symbol: '4'
    sensitivity: 2*3.14*(320e3/samp_rate)
  states: {}
- name: foo_burst_tagger_0
  id: foo_burst_tagger
  parameters:
    mult: '32'
    tag_name: pmt.intern("packet_len")
  states: {}
- name: nordic_nordic_tx_0
  id: nordic_nordic_tx
  parameters:
    channel_count: '1'
    protocol: '0'
  states: {}
- name: nordic_nordictap_transmitter_0
  id: nordic_nordictap_transmitter
  parameters:
    ack: '0'
    address: '''\x31\x30\x30\x30\x30'''
    big_packet: '0'
    channel_count: '85'
    channel_index: '0'
    crc_length: '2'
    data_rate: '1'
    payload: payload
    sequence_number: '0'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet_len"'
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: 2e6
    center_freq0: 2.485e9
    gain0: '75'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_message_strobe_0, strobe, nordic_nordictap_transmitter_0, trig]
- [blocks_repack_bits_bb_0, '0', blocks_char_to_float_0, '0']
- [digital_gfsk_mod_0, '0', foo_burst_tagger_0, '0']
- [foo_burst_tagger_0, '0', qtgui_time_sink_x_1, '0']
- [foo_burst_tagger_0, '0', uhd_usrp_sink_0, '0']
- [nordic_nordic_tx_0, '0', blocks_repack_bits_bb_0, '0']
- [nordic_nordic_tx_0, '0', digital_gfsk_mod_0, '0']
- [nordic_nordictap_transmitter_0, nordictap_out, nordic_nordic_tx_0, nordictap_in]

metadata:
  file_format: 1
